# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\library;..\..\..\components\common;..\..\..\components\public;..\..\..\components\system\protothreads\pt-1.4;..\..\..\components\system\protothreads;..\..\..\components\middleware\event;..\startup;..\app;..\services;..\plugins;..\drivers;..\mode;..\main;..\..\application;..\upgrade;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group config
    ../config/: project_config.h upgrade_config.h
  group main
    ../main/: main.c sys.c system.c stm32f10x_it.c
    ../../../components/common/: common.h
  group app
    ../app/: app.c
  group app/upgrade
    ../upgrade/: upgrade_iap.c upgrade_manager.c
  group drivers
    ../drivers/: driver.c drv_comm.c drv_flash.c drv_output.c
  group plugins
    ../plugins/: plugin_led.c
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group system
    ../../../components/system/protothreads/: thread.c
  group library
    ../../../library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
