# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,NDEBUG
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546  --diag_suppress=1295
  c include: ..\..\..\library;..\..\..\components\common;..\..\..\components\public;..\..\..\components\system\protothreads;..\..\..\components\system\protothreads\pt-1.4;..\startup;..\main;..\app;..\ui;..\services;..\plugins;..\drivers;..\..\..\third_party\lvgl;..\..\..\third_party\lvgl\src;..\..\..\third_party\lvgl\examples\porting;..\..\..\components\middleware\ui_widgets\ui_cont;..\..\..\components\middleware\ui_widgets\ui_label;..\..\..\components\middleware\ui_widgets\ui_img;..\..\..\components\middleware\ui_widgets\ui_img\img_source;..\..\..\components\middleware\ui_widgets\ui_anim;..\..\..\components\middleware\ui_widgets\ui_page_manager
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../main/: main.c stm32f4xx_it.c system.c common.h
  group app
    ../app/: app.c app_ui.c
  group ui
    ../ui/: ui_text_font.c ui_text_language.c ui_page_manager.c ui_home.c ui_weather.c
  group plugins
    ../plugins/: plugin_lcd.c plugin_lcd_font.h
  group drivers
    ../drivers/: driver.c drv_output.c drv_input.c drv_key.c drv_comm.c drv_adc.c drv_rtc.c drv_oled.c drv_pwm.c drv_timer.c drv_rgb.c drv_lcd.c
  group starup
    ../startup/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group system
    ../../../components/system/protothreads/: thread.c
  group library
    ../../../library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group middleware/ui_widgets
    ../../../components/middleware/ui_widgets/ui_cont/: ui_cont.c
    ../../../components/middleware/ui_widgets/ui_label/: ui_label.c
    ../../../components/middleware/ui_widgets/ui_img/: ui_img.c
    ../../../components/middleware/ui_widgets/ui_anim/: ui_anim.c
  group middleware/ui_widgets/img_source
    ../../../components/middleware/ui_widgets/ui_img/img_source/: TEST.c
  group third_party/lvgl/example/porting
    ../../../third_party/lvgl/examples/porting/: lv_port_disp_template.c
  group third_party/lvgl/src/core
    ../../../third_party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group third_party/lvgl/src/draw
    ../../../third_party/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../third_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group third_party/lvgl/src/extra
    ../../../third_party/lvgl/src/extra/: lv_extra.c
    ../../../third_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../third_party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../third_party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../../third_party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../third_party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../../third_party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../third_party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../third_party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../third_party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../third_party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../third_party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../third_party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../../third_party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../../third_party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../third_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../third_party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../third_party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../third_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../third_party/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../third_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../third_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../third_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../third_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../third_party/lvgl/src/extra/widgets/win/: lv_win.c
    ../../../third_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../third_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../third_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../third_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../third_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../third_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../third_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../third_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../third_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../third_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
  group third_party/lvgl/src/font
    ../../../third_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_montserrat_32.c lv_font_montserrat_36.c lv_font_montserrat_40.c lv_font_montserrat_38.c lv_font_montserrat_48.c
  group third_party/lvgl/src/hal
    ../../../third_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group third_party/lvgl/src/misc
    ../../../third_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group third_party/lvgl/src/widgets
    ../../../third_party/lvgl/src/widgets/: lv_btn.c lv_img.c lv_label.c lv_slider.c lv_switch.c lv_arc.c lv_bar.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_line.c lv_objx_templ.c lv_roller.c lv_table.c lv_textarea.c
